# IAR project light_switch.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pe001,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../../../source/Components/utils; ../../../source/Components/common; ../../../source/Components/basicrf; ../../../source/Components/targets/interface; ../../../source/Components/assembly; ../../../source/Components/common/cc8051; ../../../source/Components/targets/srf05_soc; ../../../source/Components/radios/cc2530
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk51ew_cc2530b.xcl
  group application
    ../../../source/apps/light_switch/: light_switch.c
  group utilities
    ../../../source/Components/utils/: util_lcd.c util_lcd.h util_buffer.c util_buffer.h util.c util.h
  group basic rf
    ../../../source/Components/basicrf/: basic_rf.c basic_rf.h basic_rf_security.c basic_rf_security.h
  group hal/common
    ../../../source/Components/common/: hal_int.c hal_defs.h hal_types.h
    ../../../source/Components/common/cc8051/: hal_cc8051.h
    ../../../source/Components/targets/common/: hal_lcd_srf05.c
  group hal/interface
    ../../../source/Components/targets/interface/: hal_assert.h hal_mcu.h hal_lcd.h hal_button.h hal_led.h hal_joystick.h hal_digio.h hal_int.h
  group hal/rf
    ../../../source/Components/targets/interface/: hal_rf.h hal_rf_security.h
  group hal/rf/cc2530
    ../../../source/Components/radios/cc2530/: hal_rf.c hal_rf_security.c clock.h clock.c hal_mcu.c adc.h adc.c
  group hal/srf05_soc
    ../../../source/Components/targets/srf05_soc/: hal_board.h hal_board.c hal_digio.c hal_led.c hal_button.c hal_joystick.c hal_assert.c
